## base_external/package/pir-sensor/Config.in
```kconfig
config BR2_PACKAGE_PIR_SENSOR
	bool "pir sensor"
depends on BR2_LINUX_KERNEL
	help
	   pir sensor
```
